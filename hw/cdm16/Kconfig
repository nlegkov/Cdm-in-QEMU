## hw/cdm16/Kconfig
```kconfig
config CDM16_MACHINE
    bool
    default y
    depends on CDM16
    select CDM_UART
```
